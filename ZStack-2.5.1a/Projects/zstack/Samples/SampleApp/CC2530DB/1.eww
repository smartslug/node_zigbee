<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\Utilities\SerialApp\CC2530DB\SerialApp.ewp</path>
  </project>
  <batchBuild/>
</workspace>


